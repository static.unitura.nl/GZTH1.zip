Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: GZTH1.IFC
Time: 2023-12-19T13:41:18
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: GZTH1-01
In: Default Storey
Material: Wood-Concrete

# IfcBuildingElementProxy: Multikit for GZTH1
In: Default Storey
Material: Ivana Multikit (or equal)

# IfcBuildingElementProxy: Roof type 1
In: Default Storey
Material: Wood-Concrete
